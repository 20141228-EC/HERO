# Keil uVision project My_C.uvprojx, settings and files
target My_C (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: My_C +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,__CC_ARM,ARM_MATH_CM4,__TARGET_FPU_VFP,__FPU_PRESENT=1U
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Application/AlgorithmLayer;../Application/ConfigLayer;../Application/DeviceLayer;../Application/DriverLayer;../Application/DeviceLayer/Imu;../Application/DeviceLayer/Sensor;../Application/ModuleLayer;../Application/HardwareLayer;../Application/ProtocolLayer;../Application/TaskLayer;../Application/UserLayer;../Application/Support;../Application/ControlLayer;../Application/ServiceLayer;../Drivers/CMSIS/DSP
  asm include: ../Core/Inc;..\Application\DriverLayer
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c can.c dma.c iwdg.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Task
    ../Application/TaskLayer/: community_task.c control_task.c led_task.c monitor_task.c
  group Control
    ../Application/ControlLayer/: car.c car.h
  group Module
    ../Application/ModuleLayer/: chassis.c image.c gimbal.c shooting.c myrobot_def.h
  group Service
    ../Application/ServiceLayer/: Command.c
  group Device
    ../Application/DeviceLayer/: motor.c device.c KT_module.c led.c
    ../Application/DeviceLayer/Sensor/: rc_sensor.c imu_sensor.c
  group Device/Imu
    ../Application/DeviceLayer/Imu/: BMI088Middleware.c BMI088driver.c bmi.c
  group Hardware
    ../Application/HardwareLayer/: RM_motor.c HT_motor.c KT_motor.c motor_def.h motor_def.c
  group Protocol
    ../Application/ProtocolLayer/: vision_protocol.c judge_protocol.c can_protocol.c imu_protocol.c rm_protocol.c rc_protocol.c communicate_protocol.c
  group Algorithm
    ../Application/AlgorithmLayer/: crc.c PID.c rp_math.c ave_filter.c algo.h
  group Driver
    ../Application/DriverLayer/: drv_flash.c drv_uart.c drv_can.c drv_tick.c drv_tim.c driver.c drv_can.h
  group Config
    ../Application/ConfigLayer/: rp_config.h config_uart.c config_uart.h rp_user_config.h rp_driver_config.h rp_device_config.h
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
software components: CMSIS:CORE 6.1.0, CMSIS:DSP 1.16.2

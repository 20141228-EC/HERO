# Keil uVision project DM-MC02.uvprojx, settings and files
target DM-MC02 (6220000::V6.22::ARMCLANG)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.2
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2401FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: DM-MC02 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H723xx
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Application/AlgorithmLayer;../Application/ConfigLayer;../Application/DriverLayer;../Application/DeviceLayer/Imu;../Application/DeviceLayer/Sensor;../Application/DeviceLayer;../Application/HardwareLayer;../Application/ModuleLayer;../Application/ProtocolLayer;../Application/SolvingLayer;../Application/TaskLayer;../Application/UserLayer;../Application/ServiceLayer;../Application/ParameterLayer;../Application/ControlLayer
  asm include: ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x20000
  scatter file: .\DM-MC02\DM-MC02.sct
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c fdcan.c iwdg.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Task
    ../Application/TaskLayer/: control_task.c Command_Task.c monitor_task.c observe_task.c UI_Task.c
  group Control
    ../Application/ControlLayer/: Balance.c
  group Module
    ../Application/ModuleLayer/: Chassis.c gimbal.c gimbal.h shoot.c shoot.h shoot_base.c shoot_base.h ui.c ui.h
  group Service
    ../Application/ServiceLayer/: Command.c Command_Instance.c posture.h posture.c
  group Parameter
    ../Application/ParameterLayer/: Straight_Instance.c Link_instance.c Filter.c PID_Instance.c car_info.h
  group Solving
    ../Application/SolvingLayer/: Straight_Leg_Calc.c Link_Calc.c Chassis_Posture.c ui_priority.c ui_priority.h
  group Algorithm
    ../Application/AlgorithmLayer/: algo.c ave_filter.c kalman_filter.c PID.c rp_math.c crc.c crc.h LaserRanging_kalman.h
  group Imu
    ../Application/AlgorithmLayer/: LaserRanging_kalman.c
    ../Application/DeviceLayer/Imu/: bmi.c bmi_EKF.c BMI088driver.c BMI088Middleware.c
  group Device
    ../Application/DeviceLayer/: chassis_motor.c gimbal_motor.c device.c cap.c judge.c shoot_motor.c shoot_motor.h
    ../Application/DeviceLayer/Sensor/: imu_sensor.c rc_sensor.c
  group Protocol
    ../Application/ProtocolLayer/: can_protocol.c rc_protocol.c cap_protocol.c judge_protocol.c communicate.c communicate.h ui_protocol.c ui_protocol.h LaserRanging_Protocol.c LaserRanging_Protocol.h RP_Log.c RP_Log.h
  group Driver
    ../Application/DriverLayer/: driver.c drv_can.c drv_tick.c drv_uart.c drv_tim.c drv_flash.c drv_flash.h
  group Hardware
    ../Application/HardwareLayer/: DM_Motor.c RM_motor.c HT_Motor.c motor_def.c motor_def.h
  group Config
    ../Application/ConfigLayer/: rp_config.h rp_device_config.h rp_driver_config.h rp_user_config.h
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
software components: CMSIS:CORE 6.1.1, CMSIS:DSP 1.16.2
